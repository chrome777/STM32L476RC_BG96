# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h
  ICCARM.CCIncludePath2: ../../Application/; ../../Application/BG96; ../../Application/MQTT; ../../Core/Config; ../../Core/Inc; ../../Drivers/BSP/Common; ../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../Drivers/CMSIS/Include; ../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/cJSON; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src; ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Core\Config
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Config
    ../../Core/Config/: FreeRTOSConfig.h
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
    ../../Core/Inc/: stm32l4xx_hal_conf.h
  group Application/Modules
    ../../Application/: dev_mem.c dev_mem.h dev_utils.c dev_utils.h malloc.c malloc.h
  group Application/Modules/BG96
    ../../Application/BG96/: bg96.c bg96.h bg96_conf.h bg96_io.c bg96_io.h
  group Application/Modules/MQTT
    ../../Application/MQTT/: paho_mqtt_platform.c paho_mqtt_platform.h
  group Drivers/BSP/Common
    ../../Drivers/BSP/Common/: gpio.c gpio.h iwdg.c iwdg.h rtc.c rtc.h spi.c spi.h
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/cJSON
    ../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_OS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/paho.mqtt/MQTTClient-C
    ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/paho.mqtt/MQTTPacket
    ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
