# Keil uVision project Project.uvprojx, settings and files
target Project (6090000::V6.9::.\ARMCLANG)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32L476xx,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h
  c include: E:\Program Files (x86)\MDK ARM\KEIL V5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Include;../../Core/Inc;../../Drivers/BSP/Common;../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../Drivers/CMSIS/Include;../../Drivers/STM32L4xx_HAL_Driver/Inc;../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../Middlewares/Third_Party/cJSON;../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../Modules/BG96;../../Modules/MQTT
  asm include: ..\..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
    ../../Core/Inc/: stm32l4xx_hal_conf.h
  group BSP/Common
    ../../Drivers/BSP/Common/: dev_mem.c gpio.c iwdg.c rtc.c spi.c usart.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c portmacro.h
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/cJSON
    ../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/MQTTClient-C
    ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/MQTTPacket
    ../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Modules/BG96
    ../../Modules/BG96/: bg96.c bg96.h bg96_conf.h bg96_io.c bg96_io.h
  group Modules/MQTT
    ../../Modules/MQTT/: paho_mqtt_platform.c paho_mqtt_platform.h
software components: CMSIS:CORE 5.1.2
